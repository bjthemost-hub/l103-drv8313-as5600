# Repository bjthemost-hub/l103-drv8313-as5600

File README.md:

# L103 + DRV8313 + AS5600 关节电机驱动板（软硬件 + 两级行星减速机）

[中文](README.md) | [English](README.en.md)

**CH32L103 主控 + DRV8313 三相驱动 + AS5600 磁编码器**的关节电机驱动板，跑 FOC 的固件、
调参用的上位机，以及配套的**两级行星减速机（J 版，25:1）**。

> 实拍演示：本板上电、CAN 连上位机、使能、走位、连续转速。视频里的屏幕与背景已由 AI 打码处理。

MIT License。

---

## 目录

| 目录 | 内容 |
|---|---|
| `hardware/` | KiCad 工程（原理图 + PCB，KiCad 10），`gerber/` 是出板文件，`docs/` 是 IO 分配与网表核对 |
| `firmware/` | CH32L103 固件（FOC + CAN + UART 命令台），Makefile 与 MounRiver Studio 工程两套都在 |
| `tools/` | 命令行小工具：CAN/UART 发命令、走位序列、扫速、编译与烧写脚本 |
| `gearbox-J/` | 两级行星减速机 J 版（25:1）：STEP / STL、渲染、尺寸图、装配说明 |
| `docs/` | 固件与软件设计说明书（同板 USB→CAN 桥那一半） |
| `media/` | 演示动图与视频 |

上位机是独立仓库：[`l103-servo-gui`](https://github.com/bjthemost-hub/l103-servo-gui)（同一套 GUI 也支持 DRV8316C 板）。

---

## 一、硬件

**设计值**（出处：`firmware/User/board.h` 顶部的网表核对注释，2026-09-18 核过一遍）：

| 项 | 值 |
|---|---|
| 主控 | `CH32L103K8U6`（QFN-32） |
| 三相驱动 | `DRV8313`（三半桥，单相使能 EN1/2/3） |
| PWM | `TIM3` 中心对齐，**20 kHz**（`board.h` `DRV_PWM_FREQ_HZ`）→ PA6/PA7/PB0 |
| 使能 | PB3 / PB4 / PB5 → EN1 / EN2 / EN3 |
| 故障 | `nFAULT` → PC14（R5 10 kΩ 上拉到 MCU 侧 +3V3） |
| 电流检测 | `INA240A2` × 2，50 V/V × 10 mΩ = **0.5 V/A**，量程约 ±3.3 A → PA1 / PA4 |
| 编码器 | `AS5600`，I2C1：**PB6 = SCL / PB7 = SDA**，12 位（4096 CPR） |
| CAN | `SN65HVD230`，PB8 = RX / PB9 = TX，**1 Mbps** |
| 调试串口 | UART1：PA9 = TX / PA10 = RX |
| 母线 | 8–60 V（DRV8313 手册），本固件卡 **8–36 V**（`board.h`），默认按 24 V 设计 |

> `nFAULT` 上拉的是 **MCU 侧**的 3V3，跟 DRV8313 有没有在板、有没有供电无关 ——
> 读到高电平只能说明它没把线拉低，不能证明驱动芯片健康。

`hardware/gerber/` 里是可直接下单的 Gerber。原理图导出件见 `hardware/L103_CANUSB_DRV8313.pdf`
和 `hardware/docs/` 里的 PNG/SVG。

## 二、固件

- 控制：PWM 20 kHz；**开环**由 3 kHz 中断推进电角度（`foc_motor.c` `DRIVE_ISR_FREQ_HZ`），
  **闭环**在主循环里跑（要读编码器，不适合塞进中断）。
- 反馈：AS5600 走 I2C1，12 位原始角，固件里做多圈累加与速度估计。
- 参数：极对数 / 堵转阈值 / 母线电压等存在 Flash 配置页，上电读回；读不到就用编译默认值。
  默认电机 `HT4310`、**14 极对**（`board.h` `MOTOR_POLE_PAIRS`）。
- 通信：CAN 1 Mbps（节点 1–63）或串口 115200，两套命令等价。完整命令表见
  `firmware/命令表与使用说明_UART与CAN_2026-09-28.md`。

### 编译

```bash
make -B TOOLCHAIN_PATH="<MounRiver>/resources/app/resources/win32/components/WCH/Toolchain/RISC-V Embedded GCC"
```

### 烧写

```bash
make flash OPENOCD='"<MounRiver>/resources/app/resources/win32/components/WCH/OpenOCD/OpenOCD/bin/openocd.exe"' \
           OPENOCD_SCRIPTS='<MounRiver>/resources/app/resources/win32/components/WCH/OpenOCD/OpenOCD/bin'
```

> **烧写会整片擦掉 Flash，包括参数页** —— 烧完要重新写一次极对数/母线电压再对齐。

也可以直接用 MounRiver Studio 2 打开 `firmware/L103_DRV8313_FOC.wvproj`，F7 编译、一键下载。

> **绝对不要开 `-flto`。** 开了之后启动文件里的 `.weak` 默认中断桩会顶掉真 ISR，
> 编得过、烧上去板子一动不动（现象是 CAN 没反应、串口也没输出）。Makefile 里已写死。

## 三、上位机与工具

- 上位机（独立仓库）：连接、设备表、对齐/使能/失能、走位、速度运动、开环测试、参数读写与存 Flash、序列、波形。
- `tools/l103_can.py`：CAN 发命令（支持达妙 DM-USB2CAN 的 30 字节信封与 CH9433 EVB 裸帧两种转接卡）。
- `tools/l103_seq.ps1`：动作序列；`tools/l103_velsweep.py`：扫速并记录跟随情况。
- `tools/focbuild.ps1` / `focflash.ps1`：编译与烧写。

## 四、减速机（J 版，25:1）

两级行星，每级 3 个行星轮，两级行星轮是**同一个零件**（共 6 个），避免「一级轮装到二级」的错装。
齿数 12 / 18 / 48，模数 0.95，整机 Ø54.811 × 27.10 mm，塑料件 10 件。
零件清单、打印参数、装配顺序、强度与转速边界见 `gearbox-J/README.md`。

> 那些是**设计值/计算值**（建模 + 解析式 + 布尔校核），没有实机打印件的实测背隙。

## 五、安全与边界

- 这是**开发板级**方案，没有做 UL/CE 之类的认证；上电前请自行确认母线与散热。
- **螺丝、外壳绝对不能碰 GND** —— 我们因此烧掉过两颗 DRV8313 和一颗 Si2319。
- 让机构动起来的第一件事永远是**开环**（不读反馈），确认转向、相电流、有没有某相不发力，再进闭环。
- 一旦发现不转、抖动、转速不跟随，**立刻停机**，不要靠抬电压硬顶。
- `A`（对齐）会强行拽转子 —— 对齐前轴必须能自由转。

## 六、关于 AI 辅助

本项目的硬件设计、固件、上位机界面、减速机模型与文档，在设计、编码、调试和写作过程中**大量使用了 AI 辅助**
（OpenAI Codex / GPT 系列模型），README 封面截图里的上位机界面也是由 AI 操作并截取的。
AI 生成的代码与文本均经人工审阅，并在真实板卡与台架上逐项验证。AI 是工具，不是作者 ——
设计取舍、验证标准与最终结论由人负责。

## 七、许可

MIT，见 `LICENSE`。硬件设计文件与固件源码同样按 MIT 发布。

## KiCad design hardware/L103_CANUSB_DRV8313.kicad_pcb

Parts:
C4: 22uF35v; C_0805_2012Metric
C5: 47uF/35V; C_1206_3216Metric
C6: 47uF/100V; C_2220_5750Metric
C10: 0.47uF; C_0603_1608Metric
C13, C28: 100n; C_0603_1608Metric
C14: 22uF/35v; C_0805_2012Metric
C16, C17, C18, C19, C23, C25, C30: 100nF; C_0603_1608Metric
C20: 1Uf; C_0603_1608Metric
C24: 10uF/63V; C_0805_2012Metric
C26, C27: 22uF/10V; C_0805_2012Metric
D3: SS16; D_SMA
D4: LED_RED; LED_0603_1608Metric
D5: BZT52C10-TP; BZT52C16S; ZENER VOLTAGE(NOM) 10V; ZENER VOLTAGE(RANGE) 9.4V~10.6V; MANUFACTURERPART BZT52C10-TP; LCSC PART NAME 耐压:10V 电流:0.2uA
D6: SMBJ28A; D_SMB; BREAKDOWN VOLTAGE 28.9V; MANUFACTURER PART SMBJ28A; LCSC PART NAME SMBJ28A
F1: SMD1812P300SLR/24/3A; L_1812_4532Metric
FB2: 600R; L_0805_2012Metric
L2: ANR4030T470M; L_APV_ANR4030; MPN ANR4030T470M; LCSC Part C6364808
Q1: Si2319CDS; SOT-23
R5, R6, R7, R25: 10k; R_0603_1608Metric
R9, R15: 100K; R_0603_1608Metric
R10: 30K1; R_0603_1608Metric
R11: 22K; R_0603_1608Metric
R19, R20: 10mR; R_0805_2012Metric
TP28: MOT_U; TestPoint_Loop_D2.50mm_Drill1.0mm
TP29: V; TestPoint_Loop_D2.50mm_Drill1.0mm
TP30: W; TestPoint_Loop_D2.50mm_Drill1.0mm
U2: LMR16006XDDCR; SOT-23-6; MPN LMR16006XDDCR; LCSC Part C87080
U6: DRV8313PWP; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.85x5.4mm_ThermalVias
U8, U10: INA240A2PW; TSSOP-8_4.4x3mm_P0.65mm

Connections:
+3V3: C10.1, C16.1, C17.1, R5.1, U8.5 (VS), U8.6 (REF2), U10.5 (VS), U10.6 (REF2); also elsewhere on the board
+3V3DC: C26.1, C27.1, L2.1, R9.1; also elsewhere on the board
+24VIN: F1.1; also elsewhere on the board
+24VSRC: C4.1, C5.1, C6.1, C13.1, C14.1, C18.2, C28.1, C30.1, D5.1 (C), D6.1 (K), FB2.2, Q1.2 (S), R25.1, U6.4 (VM), U6.11 (VM); also elsewhere on the board
/DRV8313/DRV_CP1: C19.1, U6.1 (CP1)
/DRV8313/DRV_CP2: C19.2, U6.2 (CP2)
/DRV8313/DRV_RESET: R6.2, U6.16 (RESET#)
/DRV8313/DRV_SLEEP: R7.2, U6.17 (SLEEP#)
/DRV8313/DRV_V33OUT: C20.1, R6.1, R7.1, U6.15 (V3P3OUT)
/DRV8313/DRV_VCP: C18.1, U6.3 (VCP)
/DRV8313/MOT_U: TP28.1 (1_1), U6.5 (OUT1)
/DRV8313/MOT_V: R19.1, U6.8 (OUT2), U8.2 (IN+)
/DRV8313/MOT_W: R20.1, U6.9 (OUT3), U10.2 (IN+)
/DRV8313/V: R19.2, TP29.1 (1_1), U8.3 (IN-)
/DRV8313/W: R20.2, TP30.1 (1_1), U10.3 (IN-)
EN_A: U6.26 (EN1); also elsewhere on the board
EN_B: U6.24 (EN2); also elsewhere on the board
EN_C: U6.22 (EN3); also elsewhere on the board
GND: C4.2, C5.2, C6.2, C10.2, C13.2, C14.2, C16.2, C17.2, C20.2, C24.2, C25.2, C26.2, C27.2, C28.2, C30.2, D3.2 (A), D4.1 (K), D6.2 (A), R10.1, R11.1, U2.2 (GND), U6.6 (PGND1), U6.7 (PGND2), U6.10 (PGND3), U6.12 (COMPP), U6.13 (COMPN), U6.14 (GND), U6.19 (COMPO#), U6.20 (GND), U6.21 (NC), U6.28 (GND), U6.29 (EP), U8.4 (GND), U8.7 (REF1), U10.4 (GND), U10.7 (REF1); also elsewhere on the board
MOT_A_V: U10.8 (OUT); also elsewhere on the board
MOT_B_V: U8.8 (OUT); also elsewhere on the board
unnamed: C23.1, D3.1 (K), L2.2, U2.6 (SW)
unnamed: D4.2 (A), R25.2
unnamed: D5.2 (A), Q1.1 (G), R11.2
unnamed: F1.2, Q1.3 (D)
unnamed: C23.2, U2.1 (CB)
unnamed: R9.2, R10.2, U2.3 (FB)
unnamed: R15.2, U2.4 (SHDN)
unnamed: C24.1, C25.1, FB2.1, R15.1, U2.5 (VIN)
PWM_A: U6.27 (IN1); also elsewhere on the board
PWM_B: U6.25 (IN2); also elsewhere on the board
PWM_C: U6.23 (IN3); also elsewhere on the board
nFAULT: R5.2, U6.18 (FAULT#); also elsewhere on the board

Parts:
C2, C15: 100n; C_0603_1608Metric
C3, C11, C12: 10uF; C_0603_1608Metric
C21, C22: 100nF; C_0603_1608Metric
D1: LED绿; LED_0603_GREEN
D2: LED红; LED_0603_RED
FB3: 600R; L_0603_1608Metric
J1: 1.27; PinHeader_1x04_P1.27mm_Vertical
J2: XT30PW(2+2)-M; CONN-TH_4P-XT30PW-M; MPN XT30PW(2+2)-M.G.B; LCSC Part C19268030
R1, R3, R4: 4.7k; R_0603_1608Metric
R2: 10k; R_0603_1608Metric
R12: 120R; R_0805_2012Metric
R14, R16: 22; R_0603_1608Metric
R17, R21: 860; R_0603_1608Metric
RV1: 10K; Potentiometer_Alps_RK09K_Single_Vertical
TP1: SV2; TestPoint_Pad_D1.5mm_Z
TP2: SV1; TestPoint_Pad_D1.5mm_Z
TP3: MOT_B_V; TestPoint_Pad_D1.5mm_Z
TP4: PWM_B; TestPoint_Pad_D1.5mm_Z
TP5: U2T; TestPoint_Pad_D1.5mm_Z
TP6: U2R; TestPoint_Pad_D1.5mm_Z
TP7: PME; TestPoint_Pad_D1.5mm_Z
TP8: U1R; TestPoint_Pad_D1.5mm_Z
TP9: U1T; TestPoint_Pad_D1.5mm_Z
TP11: DP; TestPoint_Pad_D1.5mm_Z
TP12: DM; TestPoint_Pad_D1.5mm_Z
TP13, TP25: GND; TestPoint_Pad_D1.5mm_Z
TP14: EN_B; TestPoint_Pad_D1.5mm_Z
TP15: EN_A; TestPoint_Pad_D1.5mm_Z
TP16: PWM_A; TestPoint_Pad_D1.5mm_Z
TP17, TP24: ADC0; TestPoint_Pad_D1.5mm_Z
TP18: MOT_A_V; TestPoint_Pad_D1.5mm_Z
TP19: +VDJ; TestPoint_Pad_D1.5mm_Z
TP20: G; TestPoint_Pad_D1.5mm_Z
TP23: +3V3; TestPoint_Pad_D1.5mm_Z
TP26: CANH; TestPoint_Pad_D1.5mm_Z
TP27: CANL; TestPoint_Pad_D1.5mm_Z
U3: CH32L103K8U6; QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm
U4: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U5: AS5600; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.1, C3.1, C12.2, C15.1, C22.2, FB3.2, R3.1, R4.1, RV1.1, TP23.1 (1_1), U3.1 (VDD), U5.1 (VDD5V), U5.2 (VDD3V3); also elsewhere on the board
+3V3DC: C11.2, C21.2, FB3.1, J1.1, U4.3 (VCC); also elsewhere on the board
+24VIN: J2.1; also elsewhere on the board
+24VSRC: TP19.1 (1_1); also elsewhere on the board
/CH32L103/BOOT1: R2.1, U3.16 (PB2/BOOT1)
/CH32L103/CAN1_RX: U3.32 (PB8), U4.4 (R)
/CH32L103/CAN1_TX: R1.1, U3.31 (BOOT0/PB9), U4.1 (D)
/CH32L103/CANH: J2.4, R12.1, TP26.1 (1_1), U4.7 (CANH)
/CH32L103/CANL: J2.3, R12.2, TP27.1 (1_1), U4.6 (CANL)
/CH32L103/Chang_Speed: RV1.2, U3.11 (PA5/ADC5)
/CH32L103/I2C1_SCL: R3.2, U3.29 (PB6/CC1), U5.7 (SCL)
/CH32L103/I2C1_SDA: R4.2, U3.30 (PB7/CC2), U5.6 (SDA)
/CH32L103/LED_ERR: R21.2, U3.3 (PC15/OSC32OUT)
/CH32L103/LED_OK: R17.2, U3.25 (PA15)
/CH32L103/OUT0: U3.4 (OSC_IN/PD0)
/CH32L103/OUT1: U3.5 (OSC_OUT/PD1)
/CH32L103/PWM_EXT: TP7.1 (1_1), U3.15 (PB1/ADC9)
/CH32L103/SV1: TP2.1 (1_1), U3.18 (PA8)
/CH32L103/SV2: TP1.1 (1_1), U3.17 (PB15)
/CH32L103/SWCLK: J1.3, U3.24 (PA14/SWCLK)
/CH32L103/SWDIO: J1.4, U3.23 (PA13/SWDIO)
/CH32L103/U1_RX: TP8.1 (1_1), U3.20 (PA10)
/CH32L103/U1_TX: TP9.1 (1_1), U3.19 (PA9)
/CH32L103/U2_RX: TP6.1 (1_1), U3.9 (PA3/ADC3)
/CH32L103/U2_TX: TP5.1 (1_1), U3.8 (PA2/ADC2)
/CH32L103/USBD+: R16.2, U3.21 (PA11/UDM)
/CH32L103/USBD-: R14.2, U3.22 (PA12/UDP)
ADC0: TP17.1 (1_1), TP24.1 (1_1), U3.6 (PA0/WKUP/ADC0)
EN_A: TP15.1 (1_1), U3.26 (PB3); also elsewhere on the board
EN_B: TP14.1 (1_1), U3.27 (PB4); also elsewhere on the board
EN_C: U3.28 (PB5); also elsewhere on the board
GND: C2.2, C3.2, C11.1, C12.1, C15.2, C21.1, C22.1, D1.1 (K), D2.1 (K), J1.2, J2.2, R1.2, R2.2, RV1.3, TP13.1 (1_1), TP20.1 (1_1), TP25.1 (1_1), U3.33 (VSS), U4.2 (GND), U4.8 (Rs), U5.4 (GND), U5.8 (DIR); also elsewhere on the board
MOT_A_V: TP18.1 (1_1), U3.7 (PA1/ADC1); also elsewhere on the board
MOT_B_V: TP3.1 (1_1), U3.10 (PA4/ADC4); also elsewhere on the board
unnamed: D1.2 (A), R17.1
unnamed: D2.2 (A), R21.1
unnamed: R14.1, TP11.1 (1_1)
unnamed: R16.1, TP12.1 (1_1)
PWM_A: TP16.1 (1_1), U3.12 (PA6/ADC6); also elsewhere on the board
PWM_B: TP4.1 (1_1), U3.13 (PA7/ADC7); also elsewhere on the board
PWM_C: U3.14 (PB0/ADC8); also elsewhere on the board
nFAULT: U3.2 (PC14/OSC32IN); also elsewhere on the board

Notes on the sheet:
| **G1H**(A 相上管 P 栅 PWM) | PA6 | TIM3_CH1, 20kHz, 有效电平=导通 | | **G2H**(B 相上管 P 栅 PWM) | PA7 | TIM3_CH2, 20kHz, 有效电平=导通 | | **G1L**(A 相下管 N 栅) | PB3 | GPIO, 高=导通(默认低) | | **G2L**(B 相下管 N 栅) | PB4 | GPIO, 高=导通(默认低) |
调舵机时要注意电压呀

Board: 2 copper layers, 49.2 x 49.2 mm, 92 parts (20 on the bottom side), 59 nets.

## Code that names these connections

File firmware/User/board.h:

#ifndef __BOARD_H
#define __BOARD_H

/* =============================================================================
 * L103_CANUSB_DRV8313 板级定义 (引脚来自网表核对 2026-09-18)
 * -----------------------------------------------------------------------------
 * PWM_A = PA6 -> U6.27 (IN1)   TIM3_CH1
 * PWM_B = PA7 -> U6.25 (IN2)   TIM3_CH2
 * PWM_C = PB0 -> U6.23 (IN3)   TIM3_CH3
 * EN_A  = PB3 -> U6.26 (EN1)
 * EN_B  = PB4 -> U6.24 (EN2)
 * EN_C  = PB5 -> U6.22 (EN3)
 * nFAULT= PC14 <- U6.18        (R5 10k 上拉到 +3V3)
 *         **注意**: R5 上拉的是 MCU 侧的 +3V3, 与 DRV8313 是否在板/是否供电无关
 *         -> PC14=1 不能证明 8313 健康, 只能说明它没把线拉低
 * 3V3   = +3V3DC --FB3--> +3V3  (来自 24V->5V->3.3V 支路)
 *         **不是** U6.15(V3P3OUT): 网表核对 2026-09-19, U6.15 只接 C20/R6/R7,
 *         即 DRV8313 自己的 nRESET/nSLEEP 上拉, 不供给板子
 * AS5600= U5   I2C1: PB6=SCL / PB7=SDA
 * UART1 = PA9(TX)  / PA10(RX)   debug 输出
 * UART2 = PA2(TX)  / PA3(RX)    命令输入 (预留)
 * USB   = PA11(D-) / PA12(D+)   CDC 命令输入
 * CAN1  = PB8(RX)  / PB9(TX)
 * RV1   = PA5 (ADC5)            调速电位器 (装在减速输出轴上)
 * MOT_A_V = PA1 (INA240A2 U10)  相电流反馈
 * MOT_B_V = PA4 (INA240A2 U8)   相电流反馈
 * ========================================================================== */

#include "ch32l103.h"

/* ---- 电机参数 (2026-09-28 起是"编译默认值", 可被 Flash 里的参数覆盖) ----
 * 为什么改成参数: 换颗电机 / 换个母线电源就要改代码重编太笨。现在极对数 / 堵转阈值 /
 * 母线电压存 Flash, 上电时 Flash 里的值覆盖这里的默认值
 * (见 pos_log 的记录格式 + motion_pv 的读取)。
 *   串口  #                看当前参数
 *         #<pp>            只设极对数
 *         #<pp>,<A>        设极对数 + 堵转阈值 (A)
 *         #0,<A>           只设堵转阈值
 *         #<pp>,<A>,<V>    三个一起设
 *         #0,0,<V>         只设母线电压 (换 36V 电源时用)
 *   CAN   0x116            同上的 CAN 版本: b0 极对数, b1..2 阈值 x0.01A,
 *                          b4..5 母线电压 x0.01V, b3 bit0=1 才是确认 (回 0x184)
 * 三条都**立刻写 Flash**。改极对数会把"已对齐"作废 (零点电角是用旧极对数算的),
 * 必须重跑对齐 ('A') —— 见 Motion_SetMotorCfg()。改母线电压不作废对齐。
 * 出厂默认值 HT4310: 用户规格表 2026-09-18 */
#define MOTOR_POLE_PAIRS        14          /* 编译默认: 14 极对 = 28 极 */

/* 参数合法范围 (越界直接拒, 不写 Flash) */
#define MOTOR_CFG_PP_MIN        1           /* 极对数下限 */
#define MOTOR_CFG_PP_MAX        64          /* 极对数上限 (设计值; 实际电机 1~50 就够) */
#define MOTOR_CFG_AMP_MIN       0.1f        /* 堵转阈值下限 A */
#define MOTOR_CFG_AMP_MAX       3.0f        /* 堵转阈值上限 A —— 采样链满量程就 ±3.3A
                                             * (INA240A2 增益 50 x 分流 10mR = 0.5 V/A,
                                             * 出处 交接文档_2026-09-19_CH32L103_FOC台架.md §2),
                                             * 再往上设也测不到 */
#define MOTOR_CFG_AMP_WARN      2.5f        /* 超过它就提示: 这颗 DRV8313 自己的峰值限流
                                             * 约 2.5A (出处 DRV8313 datasheet 首页),
                                             * 首页), 硬件会先跳 -> 固件阈值再高也没用 */

/* ---- PWM (TIM3, 中心对齐) ---- */
#define DRV_PWM_FREQ_HZ         20000u
#define DRV_PWM_ARR()           (SystemCoreClock / 2u / DRV_PWM_FREQ_HZ - 1u)

/* ---- CAN1 (PB8=RX / PB9=TX, 收发器 SN65HVD230) ----
 * 复用到 PB8/PB9 的依据: 数据手册 V2.1 表2-1-1 里 PB8 重映射功能写的是
 * "CAN1_RX_2", PB9 写的是 "CAN1_TX_2"; 注10 明确 "下划线后的数值 = AFIO 对应位
 * 的配置值", 即 CAN_RM[1:0] = 10b。
 * 波特率 1Mbps 的出处: 同板子的 CH32L103_USB2CAN_DM 工程 can_bsp.c 头注释
 * (PCLK1=48MHz, Prescaler=2 -> tq=24MHz, 1+BS1(15)+BS2(8)=24tq -> 1MHz),
 * 该工程此前已和 COM5 上的 USB-CAN 跑通过收发。
 * PCLK1=48MHz 的出处: User/system_ch32l103.c SetSysClockTo96_HSI() 第 709 行
 * RCC_PPRE1_DIV2 (HCLK 96MHz / 2)。 */
#define CAN_PRESCALER           2u
#define CAN_BS1_TQ              CAN_BS1_15tq
#define CAN_BS2_TQ              CAN_BS2_8tq

/* 发一帧的等待上限 (2026-09-29 新增)。
 * 为什么要有: 总线上没人给 ACK 时, 硬件的 TxMailbox 会一直停在 Pending, 旧代码用
 *   "空转 200000 圈" 兜底 —— 实测一次要 162 ms (最高一次 480 ms = 连堵 3 帧)。
 *   CAN_Bus_Task() 在主循环里, 每 10ms 想发一帧反馈, 于是主循环被吃满:
 *   闭环 FOC 从 ~2000 次/秒 掉到 3~7 次/秒 (2026-09-29 实测, 见命令表 铁律 #9)。
 * 1 Mbps 下一帧最多约 130us, 给 2ms 是十几倍余量; 真发不出去就 CAN_CancelTransmit 丢掉这一帧,
 *   宁可丢一帧, 也不许堵住控制环。 */
#define CAN_TX_TIMEOUT_US       2000u

/* ---- 软电流限幅的"拐点"(2026-10-06 加, 实现见 foc_pid.c: volt_limit_now) ----
 * 相电流到 motor_stall_amp 的这个比例之前**不限制**允许的相电压; 从 knee 到 stall 阈值
 * 之间线性收到 0V。目的: 这套是电压模式 FOC, 没有电流环 —— 低速反电势为 0 时环路一要
 * 满压, 电流就是 U/R 级 (2026-10-06 实测: 22V 母线 / L=12.70V 下 +700rpm 阶跃直接跳堵转)。
 * 0.75 是**设计值, 未实测**: 定得太低会误伤高速稳态 (13V 母线实测 440rpm 时稳态相电流
 * 1.8A, 占 3.0A 阈值的 60%)。
 * 2026-10-06 实测补记: knee=0.9 与 0.75 在 22V 下**顶速一样**
 * (700/1200rpm 命令都只到 ~490rpm), 也就是 0.9 换不来速度, 只多放电流
 * -> 保持 0.75 更保守。 */
#define MOTOR_ILIM_KNEE         0.75f

/* ---- 堵转保护 (阈值默认 2A, 2026-09-28 起可被 Flash 参数覆盖; 窗口/次数是设计值, 非实测) ---- */
#define MOTOR_STALL_AMP         2.0f        /* 编译默认值, 范围见 MOTOR_CFG_AMP_* */
#define MOTOR_STALL_WIN_MS      5u          /* 每个统计窗口 5ms */
#define MOTOR_STALL_WINS        3u          /* 连续 3 个窗口都超 -> 判堵转 (15ms) */

/* ---- 母线电压 / 限幅 (设计值, 非实测) ---- */
#define MOTOR_VOLTAGE_SUPPLY    24.0f       /* VM = 24V —— **编译默认值**, 2026-09-28 起
                                             * 可被 Flash 参数覆盖 (串口 '#0,0,<V>' / CAN 0x116 b4..5),
                                             * 换 36V 母线不用重编。
                                             * 2026-09-19 实测: 万用表量 VM 对 GND = 23.8V (台架电源 36V15A 调到 24V 档)。
                                             * 这个值只用于两处: (a) SVPWM 归一化 Uout = |U|/VM; (b) 上报的 VM。
                                             * 注意: 占空比乘的是**真实母线**, 真正决定最大相电压的是
                                             * `Uout <= 0.577` (线性调制上限), 即 Vbus/sqrt(3)。改这个常数不会
                                             * 提高转速上限, 只是让 L 的数值变成"真伏特"。 */
/* 母线电压参数的合法范围 (越界直接拒, 不写 Flash) */
#define MOTOR_CFG_VBUS_MIN      8.0f        /* 下限出处: DRV8313 数据手册 6.3 Recommended
                                             * Operating Conditions —— VM 8..60V
                                             * (DRV8313 datasheet 第 5 页) */
#define MOTOR_CFG_VBUS_MAX      36.0f       /* 上限出处: 用户给定的关节母线 24~36V。
                                             * DRV8313 自己允许到 60V (同上), 但本板是按 24V 母线
                                             * 设计的, 母线电容/降压支路/防反接都没核到 36V 以上,
                                             * 所以先卡 36V; 要更高先核硬件再放。 */
/* 上电默认相电压上限 (Uq/Ud 幅值), 0 = 用 vbus/sqrt(3)。
 * 2026-09-28 改: 原来固定 3.0V, 母线从 12V 换到 24V 它也不跟着变, 于是不改 'L'
 * 就一直是 3V 的出力 —— 实测台面 13V 时平衡关节只靠 0.03V 就能保持, 看着没事,
 * 可一旦要加速/抗扰/带载就不够 (3V / 6.7Ω ≈ 0.45A 相电流)。
 * 现在默认跟母线走: 13V->7.51V, 24V->13.86V, 36V->20.78V (见 Motion_ApplyBootVoltageLimit)。
 * 想强制小限幅(比如台面调试怕烧)就把这里填个正数, 运行期 'L<volts>' 仍可压小。 */
#define MOTOR_VOLTAGE_LIMIT     0.0f
#define MOTOR_VELOCITY_LIMIT    130.0f      /* rad/s 角度环输出的速度钳位 = 1241rpm
                                             * 2026-09-19 实测: 原来 20 (=191rpm) 就是转速天花板,
                                             * 跟电压/电流都无关 (CAN 的 vlim 给到 1200rpm 也只到 191rpm)。
                                             * 放开后 CAN 的 vlim 才有意义。 */
#define MOTOR_VELOCITY_LIMIT_MAX 150.0f     /* rad/s 运行时 0x115 能设到的上限 = 1432rpm */
#define MOTOR_VOLTAGE_ALIGN     2.5f        /* 对齐用电压 (设计值, 非实测)
                                             * 2026-09-19: 原来是 1.0V, 实测转子跟不上对齐扫场
                                             * (mid/end 差 0.4066 rad < 理论 2pi/14=0.4488 rad),
                                             * 导致极对数被估成 15。抬到 2.5V 让转子跟得住。 */
#define MOTOR_VEL_FILTER_ALPHA  0.9f        /* 速度低通系数 */
#define MOTOR_ANG_FF_GAIN       1.0f        /* 角度环的**轨迹速度前馈**增益 (2026-10-06 加)
                                             * 0 = 关 (退回老行为, 纯 P 跟轨迹)
                                             * 1 = 把 PV 轨迹自己的参考速度整个加到速度给定上
                                             * 只对角度环 + mode==PV_POS 生效; 手动 'P'/'V'/'T' 无影响。
                                             * 由来: 30 度阶跃实测 t90~145ms 但 t99~370ms, 尾巴是
                                             * 纯 P 的跟踪误差 (v/Pa), 不是轨迹慢。见
                                             * docs\工作报告_2026-10-06_FOC肉_角度环前馈.md */

/* ---- 母线电压 (VM) 采样 ----
 * 网表核对 2026-09-19 (work/l103_v2.net): +24VSRC 只连到 DRV8313 的 VM(4/11 脚)、
 * C13/C14/C18/C28/C30/C4/C5/C6、防反接 Q1、FB2(buck 输入)、R25(电源指示 LED) 和 TP19,
 * **没有任何分压电阻引到 MCU 的 ADC 脚** -> 这一版硬件量不到 VM。
 * 所以默认 VM_SENSE_ENABLE = 0: CS_VM_Volt() 返回配置值 voltage_power_supply,
 * 并且 VM_LOW 这条故障会标成"无采样"而不上报 (见 faults.c)。
 * 想真正量: 下版硬件从 +24VSRC 拉一级分压到 PA0 (焊盘6, 现在只接 TP17/TP24),
 * 再把这里改成 1、按实际电阻填 VM_DIVIDER_RATIO。 */
#define VM_SENSE_ENABLE     0
#define VM_ADC_CHANNEL      ADC_Channel_0
#define VM_DIVIDER_RATIO    11.0f       /* 分压比: 设计值, 硬件未做, 未实测 */
#define VM_LOW_THRESHOLD    20.0f       /* 用户给定: 母线低于 20V 报 VM_LOW */
#define VM_LOW_CLEAR        21.0f       /* 回差上限: 设计值, 未实测 */

/* ---- 回机械原点 ---- */
#define MOTION_HOME_VLIM_DEF  3.14159f  /* 默认速度上限 rad/s = 30rpm (设计值, 未实测) */

#endif

File firmware/User/main_i2conly.c (part):

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/* =============================================================================
 * 「只测 I2C」最小固件 + 单键自测  (CH32L103)
 *
 *   开:  系统时钟 + UART1(PA9 打印 / PA10 收键) + I2C1(PB6=SCL / PB7=SDA)
 *   不碰: TIM3(PWM) / TIM4 / EN_A/B/C / nFAULT / ADC / CAN / USB / PC15 / LED
 *
 *   UART1 (COM15, 115200 8N1) 发单个字符切换:
 *     a -> 方波模式: PB6/PB7 切成普通「开漏 GPIO」, 1Hz 方波, 两脚反相
 *          万用表都能量。用来判断 MCU 的脚到底有没有驱动出来。
 *     b -> 回连续 I2C 模式 (上电默认)
 *     c -> 慢速 I2C: 每 500ms 只发一次事务, 慢示波器/万用表也能抓
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    GPIO_SetBits(GPIOB, GPIO_Pin_6 | GPIO_Pin_7);       /* 先都释放 */
}

/* ------------------------------------------------------- 状态灯(PA15 LED_OK) */

static uint8_t led_on = 0u;

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    GPIO_InitTypeDef gpio;

    RCC_PB2PeriphClockCmd(RCC_PB2Periph_GPIOA, ENABLE);
    gpio.GPIO_Pin   = GPIO_Pin_15;          /* LED_OK */
    gpio.GPIO_Mode  = GPIO_Mode_Out_PP;
    gpio.GPIO_Speed = GPIO_Speed_10MHz;
    GPIO_Init(GPIOA, &gpio);
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    cfg7 = (uint8_t)((GPIOB->CFGLR >> 28) & 0x0Fu);
    clk  = ((RCC->PB1PCENR & RCC_PB1Periph_I2C1) != 0u) ? 1u : 0u;

    printf("STATE mode=%u PE=%u clk=%u STAR1=0x%04X STAR2=0x%04X CFGLR PB6=%Xh PB7=%Xh INDR PB6=%u PB7=%u\r\n",
           (unsigned)g_mode, (unsigned)pe, (unsigned)clk,
           (unsigned)I2C1->STAR1, (unsigned)I2C1->STAR2,
           (unsigned)cfg6, (unsigned)cfg7,
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    {
        g_mode = MODE_SQW;
        pins_to_gpio();
        printf("\r\n[SWQ] PB6/PB7 = \u5f00\u6f0f GPIO, 1Hz \u65b9\u6ce2(\u4e24\u811a\u53cd\u76f8). PB6 \u5148\u9ad8 500ms\r\n");
    }
    else if(c == 'b')
    {
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